# Keil uVision project OTA_BOOT.uvprojx, settings and files
target OTA_BOOT (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: OTA_BOOT +hex
  AfterMake: fromelf --bin --output .\Object\OTA_BOOT.bin .\Object\OTA_BOOT.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32W0xx_n\HAL_lib\inc;..\..\..\..\3_Device\MM32W0xx_n\Include;..\BSP\inc;..\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../3_Device/MM32W0xx_n/Source/: system_MM32W0xx.c
    ../../../../3_Device/MM32W0xx_n/Source/KEIL_StartAsm/: startup_MM32W0xx.s
  group APP
    ../APP/: main.c
  group BSP
    ../BSP/: MM32W0xx_it.c
  group Peripheral
    ../Peripheral/: delay.c sys.c uart.c
  group HAL_LIB
    ../../../../3_Device/MM32W0xx_n/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_memprotect.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
