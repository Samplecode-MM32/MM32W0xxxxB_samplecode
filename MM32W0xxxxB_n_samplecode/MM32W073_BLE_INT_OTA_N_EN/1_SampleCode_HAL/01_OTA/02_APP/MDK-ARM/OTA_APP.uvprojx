# Keil uVision project OTA_APP.uvprojx, settings and files
target MM32W0xx_n (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: OTA_APP +hex
  AfterMake: fromelf --bin --output .\Objects\OTA_APP.bin .\Objects\OTA_APP.axf
  c flags: Optim=1 wLevel=1
  c define: DEVICE_INFO_SUPPORT USE_UART USE_AT_CMD
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32W0xx_n\HAL_lib\inc;..\..\..\..\3_Device\MM32W0xx_n\Include;..\APP\inc;..\BSP\inc;..\Peripheral\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001010 size 0xeff0
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group STARTUP
    ../../../../3_Device/MM32W0xx_n/Source/: system_MM32W0xx.c
    ../../../../3_Device/MM32W0xx_n/Source/KEIL_StartAsm/: startup_MM32W0xx.s
  group APP
    ../APP/: main.c
  group BSP
    ../BSP/: app.c AT_CMD.c callback.c
    ../BSP/lib/: mg_BLEOTA_lib_m0.lib
  group Peripheral
    ../Peripheral/: delay.c IRQ_RF.c iwdg.c led_mesh.c rcc.c spi.c sys.c uart.c wrflash.c
  group HAL_LIB
    ../../../../3_Device/MM32W0xx_n/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_memprotect.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group README
    ../: README.txt
